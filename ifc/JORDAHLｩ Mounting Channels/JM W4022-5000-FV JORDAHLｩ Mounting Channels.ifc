Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Projektnummer
Time: 2018-03-12T16:40:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 12 16:40:47 2018 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{45A72179-BE01-42FC-BA70-538A5CF702FF}\ifc * Database version: 5507 * Database creation date: Mon Mar 12 16:40:46 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 12 16:40:46 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 12 16:40:46 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Grafiken(Type) - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene

# IfcFastener: JM W40/22 - L, JM W JORDAHL® Mounting Channels:JM W40/22 - L:375489
In: Ebene 0
Type - Material: Stahl, Edelstahl
Type - Abhängigkeiten(Type) - Vorgabe-Ansicht: 1.2192 m
Type - Abmessungen(Type) - b: 0.04 m; b3: 0.02 m; d: 0.018 m; f: 0.006 m; f1: 0.003 m; h: 0.022 m; t1: 0.0025 m; t2: 0.0025 m
Type - ID-Daten(Type) - Beschreibung: JORDAHL® mounting channels JM W, together with the appropriate hooked-head T-bolts and the JORDAHL® accessories, create a versatile channel-T-bolt connection that can be adapted to new support and fastening requirements. They can absorb tensile and shear loads vertical to the channel axis.; Hersteller: JORDAHL GmbH; LOD: 350; Modell: JM mounting channel; Typenkommentare: hot-rolled; Typname: JM W40/22 - L; URL: www.jordahl.de; Version: 2017-01
Type - Sonstige(Type) - Kategorie: Anschluss; Familienname: JM W JORDAHL® Mounting Channels
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL GmbH
Abhängigkeiten - Assessment ETA-15/0386: http://downloads.jordahl-group.com/files/approvals/ETA-15-0386_JORDAHL_Mounting_Channels_JM.pdf; Basisbauteil: <nicht verknüpft>; desgin aid: http://downloads.jordahl-group.com/files/brochures/Tech_Info_MT_2015_06_25.pdf; Ebene: Ebene: Ebene 0; Erhebung: 3 m; L: 5 m; website: http://www.jordahl-group.com/en/321/products/mounting-technology/mounting-channels-jm-w/
Abmessungen - Fläche: 0.511789 m2; Volumen: 0.00135044 m3
ID-Daten - tender text: "JORDAHL® Montageschienen Profil JM W 40/22 oder gleichwertig, geeignet für JORDAHL® Schraube JC, Oberflächen walzblank (wb), feuerverzinkt (fv) oder Edelstahl (A4), Schienen in Längen von ca. 6.000 mm liefern, Länge anpassen und montieren. Material bitte auswählen."
Materialien und Oberflächen - hot-dip galvanised: yes; material: Stahl, Edelstahl; stainless steel: no
Phasen - Phase erstellt: Phase 1
Sonstige - Bauteillistenebene: Ebene: Ebene 0; Familie: JM W JORDAHL® Mounting Channels: JM W40/22 - L; Familie und Typ: JM W JORDAHL® Mounting Channels: JM W40/22 - L; Kategorie: Anschluss; Typ: JM W JORDAHL® Mounting Channels: JM W40/22 - L; Typ-ID: JM W JORDAHL® Mounting Channels: JM W40/22 - L
