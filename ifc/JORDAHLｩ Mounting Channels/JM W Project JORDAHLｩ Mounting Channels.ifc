Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2018-03-12T16:51:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 12 16:51:41 2018 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{37E5D3B8-FF1D-4E82-B665-E9C300626662}\ifc * Database version: 5507 * Database creation date: Mon Mar 12 16:51:36 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 12 16:51:37 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 12 16:51:37 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m

# IfcBuildingElementProxy: TraceParts (5)
In: Ebene 0
Pset_BuildingElementProxyCommon - Reference: TraceParts
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL
Name
m_16_jgm_b:TraceParts:378607
jb_m20-75_-_8_8:TraceParts:378613
m_20_jgm_a:TraceParts:379365
jkc_m16-60_-_8_8:TraceParts:380869
jkb_m20-60_-_8_8:TraceParts:385573

# IfcFastener: JM W40/22 - L, JM W JORDAHL® Mounting Channels:JM W40/22 - L:376049
In: Ebene 0
Type - Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: Jordahl GmbH

# IfcFastener: JM W50/30 - L, JM W JORDAHL® Mounting Channels:JM W50/30 - L:376211
In: Ebene 0
Type - Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: Jordahl GmbH

# IfcFastener: JM W53/34 - L, JM W JORDAHL® Mounting Channels:JM W53/34 - L:376413
In: Ebene 0
Type - Material: Steel

# IfcFastener: JM W55/42 - L, JM W JORDAHL® Mounting Channels:JM W55/42 - L:376525
In: Ebene 0
Type - Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: Jordahl GmbH

# IfcFastener: JM W72/48 - L, JM W JORDAHL® Mounting Channels:JM W72/48 - L:376641
In: Ebene 0
Type - Material: Steel
Pset_ManufacturerTypeInformation - Manufacturer: Jordahl GmbH
